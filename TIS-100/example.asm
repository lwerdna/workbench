@0
MOV UP, DOWN

@1


@2


@3


@4
MOV UP, DOWN

@5
MOV UP, RIGHT

@6
MOV LEFT, ACC
MOV ACC, RIGHT
JGZ WRITE1
MOV 0, DOWN
JRO -4
WRITE1:
MOV 1, DOWN

@7
MOV LEFT, ACC
MOV ACC, RIGHT
JEZ WRITE1
MOV 0, DOWN
JRO -4
WRITE1:
MOV 1, DOWN

@8
MOV LEFT, ACC
JLZ WRITE1
MOV 0, DOWN
JRO -3
WRITE1:
MOV 1, DOWN
